include elixir.inc

SRCREV = "c88ecdec1655b04f88e3caef22f050bb85740e4c"
SRC_URI = "git://github.com/elixir-lang/elixir;branch=v1.10"

PR = "r0"
